# Keil uVision project AT32Prog.uvprojx, settings and files
target Measuring_circuit_AT32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: -AT32F407AVCT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.0.8
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AT32Prog
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\bsp;.\cmsis;.\debug;.\firmware;.\include;.\ldscripts;.\Listings;.\Objects;.\SVD;.\user
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group bsp
    ./bsp/: at32f403a_407_board.c
  group cmsis
    ./cmsis/: startup_at32f403a_407.s system_at32f403a_407.c
  group debug
    ./debug/bsp/: at32f403a_407_board.o
    ./debug/cmsis/: startup_at32f403a_407.o system_at32f403a_407.o
    ./debug/firmware/: at32f403a_407_acc.o at32f403a_407_adc.o at32f403a_407_bpr.o at32f403a_407_can.o at32f403a_407_crc.o at32f403a_407_crm.o at32f403a_407_dac.o at32f403a_407_debug.o at32f403a_407_dma.o at32f403a_407_emac.o at32f403a_407_exint.o at32f403a_407_flash.o at32f403a_407_gpio.o at32f403a_407_i2c.o at32f403a_407_misc.o at32f403a_407_pwc.o at32f403a_407_rtc.o at32f403a_407_sdio.o at32f403a_407_spi.o at32f403a_407_tmr.o at32f403a_407_usart.o at32f403a_407_usb.o at32f403a_407_wdt.o at32f403a_407_wwdt.o at32f403a_407_xmc.o
    ./debug/user/: at32f403a_407_clock.o at32f403a_407_int.o can_interrupt.o main.o spi_interrupts.o tmr_interrupt.o usart_interrupts.o
  group firmware
    ./firmware/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group include
    ./include/: at32f403a_407_board.h at32f403a_407_clock.h at32f403a_407_conf.h at32f403a_407_int.h interrupts.h
    ./include/libraries/cmsis/cm4/core_support/: arm_common_tables.h arm_const_structs.h arm_helium_utils.h arm_math.h arm_mve_tables.h arm_vec_math.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h mpu_armv8.h pmu_armv8.h
    ./include/libraries/cmsis/cm4/device_support/: at32f403a_407.h at32f403a_407_conf_template.h system_at32f403a_407.h
    ./include/libraries/drivers/inc/: at32f403a_407_acc.h at32f403a_407_adc.h at32f403a_407_bpr.h at32f403a_407_can.h at32f403a_407_crc.h at32f403a_407_crm.h at32f403a_407_dac.h at32f403a_407_debug.h at32f403a_407_def.h at32f403a_407_dma.h at32f403a_407_emac.h at32f403a_407_exint.h at32f403a_407_flash.h at32f403a_407_gpio.h at32f403a_407_i2c.h at32f403a_407_misc.h at32f403a_407_pwc.h at32f403a_407_rtc.h at32f403a_407_sdio.h at32f403a_407_spi.h at32f403a_407_tmr.h at32f403a_407_usart.h at32f403a_407_usb.h at32f403a_407_wdt.h at32f403a_407_wwdt.h at32f403a_407_xmc.h
  group ldscripts
    ./ldscripts/: AT32F407xG_FLASH.ld
  group SVD
    ./SVD/: AT32F407xx_v2.svd
  group user
    ./user/: at32f403a_407_clock.c at32f403a_407_int.c can_interrupt.c main.c spi_interrupts.c tmr_interrupt.c usart_interrupts.c
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.10.0, Device:startup 2.0.0
